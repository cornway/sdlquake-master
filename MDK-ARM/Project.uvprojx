# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F769xx,USE_HAL_DRIVER,USE_STM32F769I_DISCO,DATA_IN_ExtSDRAM,USE_LCD_HDMI,USE_USB_HS,__QEMBED__
  c include: ..\Common\STM32F7xx_Driver\Inc;..\Common\STM32F7xx_Driver\BSP\Components\Common;..\Common\STM32F7xx_Driver\BSP\STM32F769I-Discovery;..\Common\STM32F7xx_Driver\CMSIS\Device\ST\STM32F7xx\Include;..\Common\FatFs\src;..\Common\Utilities\JPEG;..\Inc;..\sdlquake-master;..\common\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\memsch1.sct
  group Drivers/STM32F7xx_HAL_Driver
    ../Common/STM32F7xx_Driver/Src/: stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal.c stm32f7xx_hal_rcc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_jpeg.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dsi.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_i2s.c stm32f7xx_ll_spi.c stm32f7xx_hal_spi.c stm32f7xx_hal_qspi.c stm32f7xx_hal_hcd.c stm32f7xx_ll_usb.c
    ../common/STM32F7xx_Driver/Src/: stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_usart.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FatFs/Option
    ../Common/FatFs/src/option/: syscall.c unicode.c
  group Example/MDK-ARM
    ./: startup_stm32f769xx.S
  group Example/User
    ../Src/: stm32f7xx_hal_msp.c main.c stm32f7xx_it.c i_sdlsound.c STUB.c
  group Drivers/BSP/Components
    ../Common/STM32F7xx_Driver/BSP/Components/adv7533/: adv7533.c
    ../Common/STM32F7xx_Driver/BSP/Components/otm8009a/: otm8009a.c
    ../Common/STM32F7xx_Driver/BSP/Components/ft6x06/: ft6x06.c
    ../Common/STM32F7xx_Driver/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32F769I_Discovery
    ../Common/STM32F7xx_Driver/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c stm32f769i_discovery_lcd.c stm32f769i_discovery_sd.c stm32f769i_discovery_sdram.c stm32f769i_discovery_ts.c stm32f769i_discovery_audio.c stm32f769i_discovery_qspi.c
  group Middlewares/FatFs/Core
    ../Common/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group usbh
    ../Common/: usbh_conf.c usbh_core.c usbh_ctlreq.c usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c usbh_ioreq.c usbh_pipes.c
  group sdlquake
    ../sdlquake-master/: cd_sdl.c chase.c cl_demo.c cl_input.c cl_main.c cl_parse.c cl_tent.c cmd.c common.c console.c crc.c cvar.c d_edge.c d_fill.c d_init.c d_modech.c d_part.c d_polyse.c d_scan.c d_sky.c d_sprite.c d_surf.c d_vars.c d_zpoint.c draw.c host.c host_cmd.c keys.c mathlib.c menu.c model.c nonintel.c pr_cmds.c pr_edict.c pr_exec.c r_aclip.c r_alias.c r_bsp.c r_draw.c r_edge.c r_efrag.c r_light.c r_main.c r_misc.c r_part.c r_sky.c r_sprite.c r_surf.c r_vars.c sbar.c screen.c snd_sdl.c sv_main.c sv_move.c sv_phys.c sv_user.c sys_sdl.c vid_sdl.c view.c vregset.c wad.c world.c zone.c snd_mem.c net_loop.c net_main.c net_none.c net_vcr.c
  group common
    ../common/: heap.c audio_main.c input_main.c lcd_main.c mach_stub.c music_main.c sd_diskio.c usb_hid_gamepad.c audio_mem.c retarget.c audio_mix.c serial.c nvic.c
    ../common/inc/: dev_conf.h nvic.h
software components: CMSIS:CORE 5.1.2
